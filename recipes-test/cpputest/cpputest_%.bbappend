EXTRA_OECMAKE = "-DLONGLONG=ON \
                 -DC++11=ON \
                 -DTESTS=OFF \
                 -DEXTENSIONS=ON \
                 "